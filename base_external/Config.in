## base_external/Config.in
```kconfig
menu "Project base external options"
	source "$BR2_EXTERNAL_project_base_PATH/package/aesd-assignments/Config.in"
endmenu
```
